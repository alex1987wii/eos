# Keil uVision project EOS.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: EOS +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: NDEBUG
  c include: .\include
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: STARTUP.A51
  group INCLUDE
    ./include/: cpu.h errno.h irq.h pin.h clock.h types.h stc89c52.h bitops.h lock.h log.h timer.h power.h watchdog.h led.h hw_timer.h memory.h
  group CORE
    ./kernel/: main.c board.c clock.c eeprom.c i2c.c irq.c key.c lcd.c led.c pin.c timer.c uart.c log.c power.c watchdog.c stc89c52.c lock.c hw_timer.c memory.c
